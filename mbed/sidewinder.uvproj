# Keil uVision project sidewinder.uvproj, settings and files
target mbed FRDM-KL46Z (ARM-ADS)
  device: MKL46Z256xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: sidewinder
  AfterMake: fromelf --bin -o build\sidewinder_KL46Z.bin build\sidewinder.axf
  c flags: Optim=1
  c define: TARGET_KL46Z,  TARGET_M0P,  TARGET_Freescale,  TARGET_KLXX,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1396163079.54,  __MBED__=1,
  c misc: --gnu
  c include: .;  mbed-rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_M0P;  mbed-rtos/rtx/TARGET_M0P/TOOLCHAIN_ARM;  mbed-rtos/rtos;  MAG3110;  mbed;  mbed/TARGET_KL46Z;  mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD;  ITG3200;  MODSERIAL;  MODSERIAL/Device;  QEI; BeagleBone; IMU; SwerveDrive; MotorDriver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/MKL46Z4.sct
  link misc: mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/startup_MKL46Z4.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/system_MKL46Z4.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL46Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    mbed-rtos/rtx/TARGET_M0P/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM0.c
    mbed-rtos/rtx/: rt_Task.c rt_System.c rt_List.c rt_Time.c rt_Semaphore.c rt_Mailbox.c rt_CMSIS.c HAL_CM.c rt_Robin.c rt_MemBox.c RTX_Conf_CM.c rt_Event.c rt_Mutex.c
    MODSERIAL/: ChangeLog.c FLUSH.cpp example2.cpp MODSERIAL.cpp example3a.cpp GETC.cpp ISR_TX.cpp example1.cpp INIT.cpp MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp ISR_RX.cpp example3b.cpp
    ./: main.cpp
    mbed-rtos/rtos/: Thread.cpp RtosTimer.cpp Semaphore.cpp Mutex.cpp
    MAG3110/: MAG3110.cpp
    ITG3200/: ITG3200.cpp
    MODSERIAL/Device/: MODSERIAL_LPC11U24.cpp MODSERIAL_KL25Z.cpp MODSERIAL_LPC1768.cpp
    QEI/: QEI.cpp
    ./BeagleBone/: BeagleBone.cpp BeagleBone.h
    ./IMU/: IMU.cpp IMU.h
    ./SwerveDrive/: SwerveDrive.cpp SwerveDrive.h
    ./MotorDriver/: MotorDriver.cpp MotorDriver.h
